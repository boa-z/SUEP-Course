ORG 0000H
AJMP MAIN
ORG 0003H
SJMP EX00
ORG 0030H

MAIN:
    SETB EA
    SETB EX0
    SETB IT0
    SETB P2.2

LNP1:
    JNB P3.3, INP1
    LCALL DELAY
    MOV P0, #0FEH
LNP2:
    LCALL DELAY
    MOV A, P0
    RL A
    MOV P0, A
    SJMP LNP2
EX00:
    CLR P2.5
    LCALL DELAY
    SETB P2.5
    LCALL DELAY
    JNB P3.3, EX00
    RETI

DELAY: MOV R3, #00
DL1:
    MOV R4, #200

DL1MS:
    NOP
    NOP
    NOP
    DJNZ R4, DL1MS
    DJNZ R3, DL1
    RET
END